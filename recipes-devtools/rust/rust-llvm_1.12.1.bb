require rust-llvm.inc
require rust-source-${PV}.inc

LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=43fdaa303c1c5589ad60f4ffc6a0b9ce"
