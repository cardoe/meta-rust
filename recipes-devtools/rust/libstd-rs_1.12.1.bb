require libstd-rs.inc
