require rust-cross.inc
